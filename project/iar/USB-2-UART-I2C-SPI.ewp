# IAR project USB-2-UART-I2C-SPI.ewp, settings and files
configuration release (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $CUTIES_CFG_DIR$; $HW_CFG_DIR$; $RTT_CFG_DIR$; $USB_CFG_DIR$; ..\..\submodule\cusblib\submodule\STM32F103C-Hardware\submodule\cuties\source; ..\..\submodule\cusblib\submodule\STM32F103C-Hardware\submodule\cuties\source\log; ..\..\submodule\cusblib\submodule\STM32F103C-Hardware\submodule\cuties\source\fifo; ..\..\submodule\cusblib\submodule\STM32F103C-Hardware\submodule\cuties\source\east; ..\..\submodule\cusblib\submodule\STM32F103C-Hardware\submodule\cuties\source\block_queue; ..\..\submodule\cusblib\submodule\STM32F103C-Hardware\submodule\cuties\source\freertos; ..\..\submodule\cusblib\submodule\STM32F103C-Hardware\submodule\cuties\source\freertos\Source\include; ..\..\submodule\cusblib\submodule\STM32F103C-Hardware\submodule\cuties\source\freertos\Source\portable\IAR\ARM_CM3; ..\..\submodule\cusblib\submodule\STM32F103C-Hardware\source\hardware; ..\..\submodule\cusblib\submodule\STM32F103C-Hardware\source\hardware\config; ..\..\submodule\cusblib\source; ..\..\source; ..\..\source\usb; ..\..\source\usb\cdc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F103C8_BluePill_Test_RealHwTemplate.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\submodule\cusblib\submodule\STM32F103C-Hardware\source\cmsis\Device\ST\STM32F1xx\Source\Templates\iar\linker\stm32f103xb_flash.icf
  ILINK.IlinkExtraOptions: --whole_archive ..\..\submodule\cusblib\submodule\STM32F103C-Hardware\submodule\cuties\project\iar\build\release\exe\cuties.a; --whole_archive ..\..\submodule\cusblib\submodule\STM32F103C-Hardware\project\iar\build\release\exe\STM32F103C-Hardware.a; --whole_archive ..\..\submodule\cusblib\project\iar\build\release\exe\cusblib.a
  ILINK.IlinkAdditionalLibs: ..\..\submodule\cusblib\submodule\STM32F103C-Hardware\submodule\cuties\project\iar\build\release\exe\cuties.a; ..\..\submodule\cusblib\submodule\STM32F103C-Hardware\project\iar\build\release\exe\STM32F103C-Hardware.a; ..\..\submodule\cusblib\project\iar\build\release\exe\cusblib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Configuration
    ../../configuration/: cuties_config.h hardware_config.h rtt_config.h usb_config.h
  group Main
    ../../source/: main.c
  group USB
    ../../source/usb/: usb_descriptor.c usb_descriptor.h
  group USB/CDC
    ../../source/usb/cdc/: cdc.c cdc.h cdc_i2c.c cdc_i2c.h cdc_private.h cdc_spi.c cdc_spi.h cdc_uart.c cdc_uart.h
